# Keil uVision project project.uvprojx, settings and files
target TrafficLightSys (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10x_LD,USE_STDPERIPH_DRIVER
  c include: .\Core;.\Lib\inc;.\Lib\src;.\Dri\LED;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ./Core/: core_cm3.c core_cm3.h startup_stm32f10x_ld.s
  group Dri/LED
    ./Dri/LED/: led.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ./User/: main.c includes.h vartypes.h stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
